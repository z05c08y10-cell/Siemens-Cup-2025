# Keil uVision project GD32F470.uvprojx, settings and files
target OLED (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F470VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GD32F470 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: GD32F470
  c include: ..\..\Drivers\CMSIS;..\..\Drivers\CMSIS\GD\GD32F4xx\Include;..\..\Drivers\GD32F4xx_standard_peripheral\Include;..\..\Drivers;..\..\Middlewares;..\..\User
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ../../Drivers/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450_470.s
  group User
    ../../User/: main.c gd32f4xx_it.c
    ../../Drivers/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/delay/: delay.c
    ../../Drivers/SYSTEM/sys/: sys.c
    ../../Drivers/SYSTEM/usart/: usart.c
  group Drivers/GD32F4xx_standard_peripheral
    ../../Drivers/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group Drivers/BSP
    ../../Drivers/BSP/LED/: led.c
    ../../Drivers/BSP/IIC/: myiic.c
    ../../Drivers/BSP/OLED/: oled.c
    ../../Drivers/BSP/KEY/: key.c
    ../../Drivers/BSP/ADC/: adc.c
    ../../Drivers/BSP/FMC/: fmc.c
    ../../Drivers/BSP/NORFLASH/: norflash.c
    ../../Drivers/BSP/RTC/: rtc.c
    ../../Drivers/BSP/SDIO/: sd_conf.c sdio_sdcard.c
    ../../Drivers/BSP/SPI/: spi.c
    ../../Drivers/BSP/TIMER/: timer.c
  group Middlewares/FATFS
    ../../Middlewares/FATFS/source/: diskio.c ff.c ffsystem.c ffunicode.c
    ../../Middlewares/FATFS/exfuns/: exfuns.c fattester.c
  group Middlewares/MALLOC
    ../../Middlewares/MALLOC/: malloc.c
  group Readme
    ../../: readme.txt
